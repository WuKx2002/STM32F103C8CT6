# Keil uVision project LED4.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED4
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Lib\STM32F10x_StdPeriph_Driver\src;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Lib
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x_it.c system_stm32f10x.c
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c key_led.c
software components: CMSIS:CORE 5.0.1
